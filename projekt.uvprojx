# Keil uVision project projekt.uvprojx, settings and files
target KL05Z (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IROM(0x00000000,0x00008000) IRAM(0x1FFFFC00,0x00001000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Cw_7 +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./src/: ADC.c DAC.c main.c pit.c uart0.c klaw.c
  group inc
    ./inc/: ADC.h DAC.h frdm_bsp.h main.h pit.h uart0.h klaw.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
